# Repository poesel/TTGO-T8-Bee-Scale

File README.md:

# TTGO-T8-Bee-Scale
bee scale with ttgo t8 esp32 bme280 ds18b20 hx711

## KiCad design KiCAD Files/ESP32 Waage.kicad_pcb

Parts:
C1, C3: 47uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C4, C5: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: 3.3V spare; PinSocket_1x02_P2.54mm_Vertical
J2: Ext. Power Supply 5V; PhoenixContact_FFKDSV_381_2_pol
J3: spare; PinHeader_1x08_P2.54mm_Vertical
J4, J7: spare; PinHeader_1x02_P2.54mm_Vertical
J5: 5V spare; PinSocket_1x02_P2.54mm_Vertical
J6: spare; PinHeader_1x05_P2.54mm_Vertical
J8: Scale Terminal; PhoenixContact_FFKDSV_381_7_pol
J9: DS18B20 Term.; PhoenixContact_FFKDSV_381_3_pol
J10: I2S Terminal; PhoenixContact_FFKDSV_381_6_pol
J11: I2C Terminal; PhoenixContact_FFKDSV_381_4_pol
R1, R2, R3: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_SPST; SW_CuK_JS202011CQN_DPDT_Straight
U1: SN74LVC1T45DBV; SOT-23-6
U2: ESP32WROVERSocket; TTGO_T8_Socket
U3: HX711Socket; HX711_Socket

Connections:
21: U1.3 (A), U2.21
32: U2.32, U3.2
33: J9.2, R3.1, U2.33
+3V3: C3.2, C5.2, J1.1, J9.1, J10.1, J11.3, R1.2, R2.2, R3.2, U1.1 (VCCA), U2.3V3
+5V: C1.1, C2.1, C4.2, J5.1, SW1.1 (A), U1.6 (VCCB), U2.5V, U3.1
+5VL: J2.2, SW1.2 (B)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, J1.2, J2.1, J5.2, J8.1, J8.3, J9.3, J10.2, J10.6, J11.4, U1.2 (GND), U1.5 (DIR), U2.GND, U3.4, U3.6
unnamed: J3.1, U2.TXD
unnamed: J3.2, U2.RXD
unnamed: J3.3, U2.22
unnamed: J3.4, U2.19
unnamed: J3.5, U2.23
unnamed: J3.6, U2.18
unnamed: J3.7, U2.5
unnamed: J3.8, U2.2
unnamed: J4.1, U2.0
unnamed: J4.2, U2.4
unnamed: J6.1, U2.35
unnamed: J6.2, U2.34
unnamed: J6.3, U2.RST
unnamed: J6.4, U2.39
unnamed: J6.5, U2.36
unnamed: J7.1, U2.26
unnamed: J7.2, U2.25
unnamed: J8.2, U3.5
unnamed: J8.4, U3.7
unnamed: J8.5, U3.8
unnamed: J8.6, U3.9
unnamed: J8.7, U3.10
unnamed: U1.4 (B), U3.3
SCK: J10.5, U2.12
SD: J10.4, U2.14
SDA: J11.1, R2.1, U2.13
SDC: J11.2, R1.1, U2.15
WS: J10.3, U2.27

Notes on the sheet:
Data
L/R
SCK
3V3
GND
SDC
SDA

Board: 2 copper layers, 86.4 x 56.3 mm, 27 parts (0 on the bottom side), 35 nets.

Other parts of the board:
 : MountingHole_3.2mm_M3_Pad_Via
 #2,  #3,  #4: MountingHole_3.2mm_M3_Pad_Via

## Commit log

2020-04-12 init
2020-04-12 rename & schema
2020-04-12 dded resitors, capacitors, missing connections
2020-04-13 added I2S removed C3 removed Reed switch
2020-04-15 Optocoupler Mounting holes
2020-04-15 removed optocouplers added LVC74...
2020-04-17 added switch rearranged stuff
2020-04-17 Create LICENSE
2020-04-19 new schema layout
2020-04-24 redesign of schema added various 3D models PCB
2020-05-01 change from 2,54 terminals to 3,81 because of availability removed internal I2C & BME280 added mounting holes
